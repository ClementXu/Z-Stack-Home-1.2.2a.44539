<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zha_project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>zha_project</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>zha_project</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>zha_project</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>zha_project</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


